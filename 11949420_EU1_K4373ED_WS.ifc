Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-04T12:37:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 04 12:37:03 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\65144e2e-6c02-4ec3-a9f7-b7ba11816c6d\76e8c7da-3eff-473e-8047-7f370aee8b2a\ifc * Database version: 5507 * Database creation date: Wed Jan 04 12:37:02 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 04 12:37:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 04 12:37:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11949420_EU1_K4373ED_WS:36437354_EU1_11949420_K4373ED_WS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 36437354_EU1_11949420_K4373ED_WS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 36437354_EU1_11949420_K4373ED_WS
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1855 mm; Depth: 675 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355316
Description: Flow; FlowDirection: SOURCEANDSINK
